Commit message: [Cart.urdf] Delete empty axis.

File: description/urdf/Cart.urdf (robot description, URDF)
Before this commit: robot Cart, 2 links, 1 joints
Joints:
- joint Body: axis    -> (none)
